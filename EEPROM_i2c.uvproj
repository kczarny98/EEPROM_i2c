# Keil uVision project EEPROM_i2c.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2132/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: I2C_ADV +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s i2c.c main.c pcf.c mc24lc64.c command_decoder.c string.c uart.c led.c
